# Keil uVision project HX43UCRRL.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC92F7322 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(24000000)
  output: OSAL_Demo +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\app;..\port;..\task;..\hal;..\osal
  group pro
    ./: STARTUP.A51 main.c
  group task
    ../task/: app_task.c heat_cool_task.c msge_task.c pushrod_task.c
  group osal
    ../osal/: OSAL.c OSAL_Tasks.c OSAL_Timer.c
  group port
    ../port/: port_pushrod.c port_heat_cool.c port_msge.c
  group hal
    ../hal/: hal_pushrod.c hal_timer.c hal_heat_cool.c hal_msge.c hal_uart.c hal_init.c
